# Keil uVision project ProductCode.uvprojx, settings and files
target User (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: littilefs +hex
  AfterMake: fromelf.exe --bin -o ../Obj/calibration.bin ../User/calibration.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F103xE,HSE_VALUE=8000000
  c include: ..\..\drivers\mcu\CMSIS\Include;..\..\drivers\mcu\CMSIS\Device\ST\STM32F1xx\Include;..\..\drivers\mcu\STM32F1xx_HAL_Driver\Inc;..\..\components\sfud\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group sfud
    ../../components/sfud/src/: sfud.c sfud_sfdp.c
  group lfs
    ../../components/lfs/: lfs.c lfs_util.c
  group drivers/mcu/mcu_hal
    ../../drivers/mcu/: hal_mcu.c hal_clk.c hal_gpio.c hal_uart.c hal_spi.c
  group drivers/mcu/mcu_lib
    ../../drivers/mcu/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
    ../../drivers/mcu/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../drivers/mcu/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group user
    ../../user/: main.c fs_user.c
    ../../components/sfud/port/: sfud_port.c
